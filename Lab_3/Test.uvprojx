# Keil uVision project Test.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1 wLevel=2
  c misc: --c99
  asm include: ..\TEST
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Clock.c SerialDriver.c LedDriver.c TimerDriver.c TimingTest.c main.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
